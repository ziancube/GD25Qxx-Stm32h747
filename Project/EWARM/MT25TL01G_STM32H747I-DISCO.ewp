# IAR project MT25TL01G_STM32H747I-DISCO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747I-DISCO_M7 ST STM32H747I-DISCO_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS; ..\..\Includes\Library; ..\..\Includes\Loader
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MT25TL01G_STM32H747I-DISCO.srec
  ILINK.IlinkOutputFile: GD25Qxx-ZIANCube-4MB.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Docs
    ../../: readme.txt ReleaseNotes.txt
  group Library
    ../../Sources/Library/: qspi_flash.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c system_stm32h7xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
